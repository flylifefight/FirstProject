# Keil uVision project first_fly.uvprojx, settings and files
target APP (6220000::V6.22::ARMCLANG)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first_fly +hex
  AfterMake: fromelf --bin -o "Out\app.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\src;..\bsp;..\library\GD32F30x_standard_peripheral\Include;..\library\CMSIS\GD\GD32F30x\Include;..\library\CMSIS;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ../src/: main.c gd32f30x_it.c
  group library
    ../library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_timer.c gd32f30x_usart.c
    ../library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group bsp
    ../bsp/: bsp_adc.c bsp_flash.c bsp_timer.c bsp_usart.c bsp_systick.c
